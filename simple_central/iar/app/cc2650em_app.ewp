# IAR project cc2650em_app.ewp, settings and files
configuration FlashROM (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: xBOARD_DISPLAY_EXCLUDE_UART; xCC2650DK_7ID; CC2640_4XS; TELE_REMOTE; FPGA_; CC26XX; GAPCENTRALROLE_NUM_RSSI_LINKS=1; HEAPMGR_SIZE=0; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; POWER_SAVING; USE_ICALL; BOARD_DISPLAY_EXCLUDE_LCD; Display_DISABLE_ALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL; FPGA_AUTO_CONNECT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_EX$/config/build_components.opt; -f ..\stack\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; -f ..\config\iar_boundary.bdef
  ICCARM.CCIncludePath2: $SRC_BLE_CORE$/controller/cc26xx/inc; $SRC_BLE_CORE$/inc; $SRC_EX$/common/cc26xx; $SRC_EX$/icall/inc; $SRC_EX$/inc; $SRC_EX$/profiles/roles; $SRC_EX$/profiles/roles/cc26xx; $SRC_EX$/profiles/simple_profile; ..\..\..\target; $SRC_COMMON$/hal/src/inc; $SRC_COMMON$/hal/src/target/_common; $SRC_COMMON$/hal/src/target/_common/cc26xx; $SRC_COMMON$/hal/src/target/cc2650/rom; $SRC_COMMON$/heapmgr; $SRC_COMMON$/icall/src/inc; $SRC_COMMON$/osal/src/inc; $SRC_COMMON$/services/src/saddr; $SRC_COMMON$/services/src/sdata; $CC26XXWARE$; $TI_RTOS_DRIVERS_BASE$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simple_central_cc2650em_app.hex
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: simple_central_cc2650em_app.out
  ILINK.IlinkIcfFile: $SRC_EX$/common/cc26xx/iar/cc26xx_app.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\iar_boundary.xcl
  ILINK.IlinkAdditionalLibs: $ROM$\common_rom_releases\03282014\common_rom.symbols; $CC26XXWARE$\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../target/: hw_gpio.c hw_gpio.h hw_key.c hw_key.h
    ../../src/app/: simple_central.c simple_central.h
    ../../../../../src/common/cc26xx/: util.c util.h
  group Drivers/Display
    $TI_RTOS_DRIVERS_BASE$/ti/mw/display/: Display.c Display.h DisplayUart.c DisplayUart.h
  group Drivers/ECC
    ../../../../../src/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/PIN
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/: PIN.h
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/pin/: PINCC26XX.c PINCC26XX.h
  group Drivers/RF
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/rf/: RF.h RFCC26XX_singleMode.c
  group Drivers/TRNG
    ../../../../../src/components/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group Drivers/UDMA
    $TI_RTOS_DRIVERS_BASE$/ti/drivers/dma/: UDMACC26XX.c UDMACC26XX.h
  group ICall
    ../../../../../src/components/heapmgr/: heapmgr.h
    ../../../../../src/components/icall/src/: icall.c icall_cc2650.c icall_platform.h
    ../../../../../src/components/icall/src/inc/: icall.h
    ../../../../../src/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../src/icall/app/: ble_user_config.c icall_api.c
    ../../../../../src/icall/inc/: ble_user_config.h icall_apimsg.h
  group Include
    ../../../../../src/inc/: gap.h gapgattserver.h gatt.h hci.h
    ../../../../../src/profiles/roles/: gapbondmgr.h
    ../../../../../src/components/osal/src/inc/: osal_snv.h
  group Profiles
    ../../../../../src/profiles/roles/cc26xx/: central.c central.h
  group Startup
    ../../../target/: board.c
    ../config/: ccfg_app_ble.c
    ../../src/app/: main.c
  group Tools
    ../config/: app_ble.cfg iar_boundary.bdef iar_boundary.xcl
    ../../../../../src/common/cc26xx/iar/: cc26xx_app.icf
